Commit message: Add collision for cart

File: cart.urdf (robot description, URDF)
Before this commit: robot cart, 3 links, 2 joints
Links:
- link base_link: geometry collision box size=0.3 0.3 0.1; visual box size=0.3 0.3 0.1
